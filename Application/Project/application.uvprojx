# Keil uVision project application.uvprojx, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CS32F031K8U6 Chipsea
  pack: Chipsea.CS32F03x_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: application +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Device\HAL_Driver\inc;..\..\Device\Include;..\User\app;..\User\drv;..\User\hal
  memory RVCT4: ROM 0x8001000 size 0xf000
  memory RVCT9: RAM 0x200000c0 size 0x1f40
  group startup
    ../../Device/Source/ARM/: startup_cs32f031.S
  group cmsis
    ../../Device/Source/: system_cs32f0xx.c
  group library
    ../../Device/HAL_Driver/src/: cs32f0xx_gpio.c cs32f0xx_syscfg.c cs32f0xx_pmu.c cs32f0xx_debug.c cs32f0xx_tim.c cs32f0xx_misc.c cs32f0xx_i2c.c cs32f0xx_adc.c cs32f0xx_usart.c cs32f0xx_rcu.c cs32f0xx_flash.c
  group app
    ../User/app/: main.c app_event.c app_led.c app_batt.c app_hall.c app_com.c app_flash.c
  group drv
    ../User/drv/: drv_task.c drv_timer.c drv_event.c drv_led.c drv_charger.c drv_batt.c drv_hall.c drv_com.c drv_flash.c
  group hal
    ../User/hal/: hal_interrupt.c hal_task.c hal_timer.c hal_led.c hal_charger.c hal_batt.c hal_hall.c hal_com.c
