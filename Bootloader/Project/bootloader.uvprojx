# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: CS32F031K8U6 Chipsea
  pack: Chipsea.CS32F03x_DFP.2.0.5
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\Device\HAL_Driver\inc;..\..\Device\Include;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0xc0
  memory RVCT10: RAM 0x200000c0 size 0x1f40
  group startup
    ../../Device/Source/ARM/: startup_cs32f031.S
  group cmsis
    ../../Device/Source/: system_cs32f0xx.c
  group library
    ../../Device/HAL_Driver/src/: cs32f0xx_flash.c cs32f0xx_gpio.c cs32f0xx_tim.c cs32f0xx_misc.c
  group user
    ../User/: main.c vector.c
