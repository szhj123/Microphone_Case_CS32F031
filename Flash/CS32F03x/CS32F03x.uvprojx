# Keil uVision project CS32F03x.uvprojx, settings and files
target CS32F0xx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: CS32A039_BOOT
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CS32F03x_BOOT
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
software components: CMSIS:CORE 5.2.0
